# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, STM32H743xx, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;packages\can_ymodem-v1.1.0;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\FlashDB-v1.1.2\inc;.;rt-thread\include;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Include;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;rt-thread\components\net\lwip\port;packages\network_samples-latest;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;packages\qpc-latest\ports\rt-thread;packages\qpc-latest\include;packages\qpc-latest\src;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;packages\uCOSIII_Wrapper-latest\uC-CPU;packages\uCOSIII_Wrapper-latest\uC-LIB;packages\uCOSIII_Wrapper-latest\uCOS-III;User\app;User\app;User\app\liquid;User\app;User\app\opt;User\app;User\app\air;User\base;User\base;User\base\OTA;User\bsp;User\bsp;User\bsp\tmc5160;User\bsp;User\bsp\adc128S102;User\bsp;User\bsp\ad7730;User\inc;User\lib;User\port;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ymodem
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    packages/can_ymodem-v1.1.0/: can_ymodem.c
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c dac.c pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: qspi_core.c spi-bit-ops.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    libraries/HAL_Drivers/: drv_adc.c drv_common.c drv_dac.c drv_eth.c drv_fdcan.c drv_gpio.c drv_pwm.c drv_qspi.c drv_soft_i2c.c drv_soft_spi.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_h7.c
    ./libraries/HAL_Drivers/: drv_wdt.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_rtt.c fal_partition.c fal_flash.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb.c fdb_file.c fdb_utils.c fdb_tsdb.c fdb_cmd.c fdb_kvdb.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_i2c.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_cryp.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_usart.c stm32h7xx_hal_lptim.c stm32h7xx_hal_eth.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group network-samples
    packages/network_samples-latest/: tcpclient_sample.c tcpclient_select_sample.c tcpserver_sample.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group qpc
    packages/qpc-latest/src/qf/: qep_hsm.c qf_dyn.c qf_defer.c qf_mem.c qf_qact.c qf_ps.c qep_msm.c qf_time.c qf_qmact.c qf_act.c qf_qeq.c
    packages/qpc-latest/ports/rt-thread/: qf_port.c qf_hooks.c
    packages/qpc-latest/include/: qstamp.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group uC-CPU
    packages/uCOSIII_Wrapper-latest/uC-CPU/: cpu_a.c cpu_core.c
  group uC-LIB
    packages/uCOSIII_Wrapper-latest/uC-LIB/: lib_math.c lib_str.c lib_ascii.c lib_mem.c
  group uCOS-III
    packages/uCOSIII_Wrapper-latest/uCOS-III/: os_flag.c os_time.c os_rtwrap.c os_cpu_c.c os_task.c os_app_hooks.c os_var.c os_tmr.c os_mutex.c os_pend_multi.c os_core.c os_stat.c os_mem.c os_dbg.c os_sem.c os_q.c os_cfg_app.c
  group User.app
    User/app/: User_Instruction_Task.c Pedal_User_Task.c Normal_Task.c Data_Task.c valve_task.c Sensor_Transfer_Task.c app_instruction_com.c
    User/app/opt/: Fan_Task.c Phaco_Task.c Diathermy_Task.c app_barcode.c app_instruction_opt.c
    User/app/liquid/: Reflux_Task.c Priming_Task.c SystemCheck_Task.c Sensor_Task.c Suction_Task.c Infusion_Task.c Cassette_Task.c
    User/app/air/: Pneumatic_Task.c
  group User.base
    User/base/: Task_Start.c Can_IV_Task.c Can_Rx_Task.c Tcp_Server_Task.c Data_Distribution_Task.c Flash_Task.c Tcp_Client_Task.c Engineering_Task.c Pedal_Task.c instruction_task.c Heart_Task.c Fw_DownLoad_Task.c App_ComFun.c
    User/base/OTA/: OTA_Manger_Task.c OTA_Tcp_Client_Task.c
  group User.bsp
    User/bsp/: bsp_m95512.c bsp_abstractPrsureSen.c bsp_airpressure.c bsp_fsm_btn.c bsp_timer2_pwm.c bsp_valve.c bsp_algorithm.c bsp_z4d_c01.c bsp_abstractEncode.c bsp_ws2812b.c bsp_ultrasonic_protocol.c bsp_fan.c bsp_step_motor.c bsp_timer3_capture.c bsp_timer1_pwm.c bsp_3950temp.c bsp_com_protocol.c bsp_abstractLineFunc.c bsp_diathermy.c drv_dac_mcp4725.c bsp_prsurSen.c bsp_errorlist.c bsp_step_tmc5160.c bsp_vitCtl.c bsp_pid.c bsp_can_ymodem.c bsp_adc.c bsp_timer_callback.c
    User/bsp/tmc5160/: tmc5160_api_header.c tmc5160.c
    User/bsp/ad7730/: bsp_ad7730.c
    User/bsp/adc128S102/: bsp_adc128S102.c
  group User.lib
    User/lib/: ringbufindex.c dbl-circ-list.c circular-list.c list.c dbl-list.c ringbuf.c
  group User.port
    User/port/: spi_flash_init.c fal_cfg.h
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
